Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Roger_prio1\Arbetsmapp\82041000\AutoCAD Architecture\82041000.ifc
Time: 2014-02-27T09:06:47
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 82041000
LongName: 82041000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 82041000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 82041000, BUILDINGELEMENTPROXY(1)
In: 82041000
Description: FM Mattsson 82001000, Safety mixer f/ Bath 9000E II inkl Wall Plate 40-160 c/c, chrome
